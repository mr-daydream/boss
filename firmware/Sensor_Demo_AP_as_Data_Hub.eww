<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Sensor_Demo_AP_as_Data_Hub.ewp</path>
    </project>
    <batchBuild />
</workspace>
